# Keil uVision project Goldenridge_MainV1.1.uvprojx, settings and files
target Goldenridge_MainV1.1 (5060750::V5.06 update 6 (build 750)::ARMCC)
  device: STM32F407ZGTx STMicroelectronics
  pack: Keil.STM32F4xx_DFP.2.13.0
  cpu: IRAM(0x20000000-0x2001FFFF) IRAM2(0x10000000-0x1000FFFF) IROM(0x8000000-0x80FFFFF)  CLOCK(25000000) FPU2 CPUTYPE("Cortex-M4")
  output: Goldenridge_Main +hex
  AfterMake: C:\Keil_v5\ARM\ARMCC\bin\fromelf.exe --bin -o  ./Goldenridge_MainV1.1/@L.bin  ./Goldenridge_MainV1.1/@L.axf
  AfterMake: .\merge_bin.exe
  c flags: Optim=1 OneElfS=1 uC99=1 uGnu=1 v6Lang=1 v6LangP=1 wLevel=2
  c define: USE_HAL_DRIVER,STM32F407xx,__LOG,__WDG
  c include: ../Inc;../Drivers/STM32F4xx_HAL_Driver/Inc;../Drivers/STM32F4xx_HAL_Driver/Inc/Legacy;../Drivers/CMSIS/Device/ST/STM32F4xx/Include;../Drivers/CMSIS/Include;../Middlewares/ST/STM32_USB_Device_Library/Core/Inc;../Middlewares/ST/STM32_USB_Device_Library/Class/CDC/Inc;../Middlewares/Third_Party/FreeRTOS/Source/portable/RVDS/ARM_CM4F;../Middlewares/Third_Party/FreeRTOS/Source/include;../Middlewares/Third_Party/FreeRTOS/Source/CMSIS_RTOS;..\protocol;..\Online_Update;..\joystick;..\Motor_Control;..\statemachine\states;..\Statemachine;..\Bms;..\Clock;..\Ultrasonic;..\Warn;..\Odom;..\Imu;..\New_MotorDriver;..\Tx2_Power;..\log;..\outboard_sensor;..\watchdog;..\Sys_Monitor;..\Motor_Control\common;..\Motor_Control\motor_driver;..\active_safety;..\Modbus;..\Publish;..\W5500;..\Internet;..\fault_injector;..\com;..\Frame_statistical;..\Queue;..\alarm;../Middlewares/Third_Party/FatFs/src;..\Temp_Sensor;..\stmfalsh;..\Unit_Test;..\FTP;..\Zhd;..\Unity-master\src;..\Unity-master\extras\fixture\src;..\Unity-master\examples;..\chassis_ut;..\chassis_ut\test_cases
  asm include: ..\\Inc
  library: MicroLIB
  memory RVCT4: ROM 0x800c400 size 0x70000
  memory RVCT9: RAM 0x20000000 size 0x20000
  memory RVCT10: RAM 0x10000000 size 0x10000
  group Application/MDK-ARM
    ./: startup_stm32f407xx.s
  group Drivers/STM32F4xx_HAL_Driver
    ../Drivers/STM32F4xx_HAL_Driver/Src/: stm32f4xx_hal_pcd.c stm32f4xx_hal_pcd_ex.c stm32f4xx_ll_usb.c stm32f4xx_hal_adc.c stm32f4xx_hal_adc_ex.c stm32f4xx_hal_can.c stm32f4xx_hal_crc.c stm32f4xx_hal_iwdg.c stm32f4xx_ll_sdmmc.c stm32f4xx_hal_sd.c stm32f4xx_hal_spi.c stm32f4xx_hal_tim.c stm32f4xx_hal_tim_ex.c stm32f4xx_hal_uart.c stm32f4xx_hal_rcc.c stm32f4xx_hal_rcc_ex.c stm32f4xx_hal_flash.c stm32f4xx_hal_flash_ex.c stm32f4xx_hal_flash_ramfunc.c stm32f4xx_hal_gpio.c stm32f4xx_hal_dma_ex.c stm32f4xx_hal_dma.c stm32f4xx_hal_pwr.c stm32f4xx_hal_pwr_ex.c stm32f4xx_hal_cortex.c stm32f4xx_hal.c
  group Drivers/CMSIS
    ..//Src/: system_stm32f4xx.c
  group Middlewares/USB_Device_Library
    ../Middlewares/ST/STM32_USB_Device_Library/Core/Src/: usbd_core.c usbd_ctlreq.c usbd_ioreq.c
    ../Middlewares/ST/STM32_USB_Device_Library/Class/CDC/Src/: usbd_cdc.c
  group Middlewares/FreeRTOS
    ../Middlewares/Third_Party/FreeRTOS/Source/portable/MemMang/: heap_4.c
    ../Middlewares/Third_Party/FreeRTOS/Source/portable/RVDS/ARM_CM4F/: port.c
    ../Middlewares/Third_Party/FreeRTOS/Source/: croutine.c event_groups.c list.c queue.c tasks.c timers.c
    ../Middlewares/Third_Party/FreeRTOS/Source/CMSIS_RTOS/: cmsis_os.c
  group Middlewares/FatFs
    ../Middlewares/Third_Party/FatFs/src/option/: syscall.c cc936.c
    ../Middlewares/Third_Party/FatFs/src/: diskio.c ff.c ff_gen_drv.c
  group Application/User
    ../Src/: usb_driver.c main.c gpio.c adc.c can.c crc.c dma.c bsp_driver_sd.c sd_diskio.c fatfs.c freertos.c iwdg.c sdio.c spi.c tim.c usart.c usb_device.c usbd_conf.c usbd_desc.c usbd_cdc_if.c stm32f4xx_it.c stm32f4xx_hal_msp.c stm32f4xx_hal_timebase_TIM.c
  group System/Queue
    ../Queue/: sys_queue.c
  group System/Watchdog
    ../watchdog/: watchdog_task.c
  group System/Clock
    ../Clock/: Clock.c
  group Statemachine
    ../statemachine/: chassis_fsm.c chassis_fsm.h state_base.h
    ../statemachine/states/: init_state.c ready_state.c init_state.h ready_state.h auto_state.c auto_state.h fault_state.c fault_state.h lock_state.c lock_state.h mannual_state.c mannual_state.h
  group Bms
    ../Bms/: Bms.c
  group Joystick
    ../joystick/: joystick.c joystick.h
  group Ultrasonic
    ../Ultrasonic/: Ultrasonic_New.c Ultrasonic_New.h
  group Imu
    ../Imu/: spi_driver.c imu_driver.c imu_maintain.c imu.c
  group Odom
    ../Odom/: odom.c
  group Sys_Monitor
    ../Sys_Monitor/: sys_cpu.c sys_stack.c sys_monitor.c
  group outboard_sensor
    ../outboard_sensor/: outboard_sensor.c
  group Tx2_Power
    ../Tx2_Power/: tx2_power.c
  group W5500
    ../W5500/: socket.c utility.c w5500.c w5500_conf.c
  group Internet
    ../Internet/: dhcp.c tcp_demo.c
  group Protocol
    ../protocol/: buffer.c callback.c info_callback.c info_core.c info_crc.c info_OD.c OD.c Init_Hardware.c
  group Online_Update
    ../Online_Update/: check_buffer.c Communication.c Online_Downloader.c
  group Publish
    ../Publish/: Publish_Pc.c Subscribe_Pc.c Publish_powerboard.c Subscribe_powerBoard.c Subscribe_sensorBoard.c Publish_outboard.c Publish_outboard.h
  group Frame_statistical
    ../Frame_statistical/: Frame_statistical.c
  group Motor_Control
    ../Motor_Control/: control_debug.c Motor_Control.c Motor_Control_Monitor.c Motor_PcConfig.c Control_selfmodify.c Pub_ControlInfo.c
  group Motor_Control/motor_driver
    ../Motor_Control/motor_driver/: motor_driver.c motor_driver_common.c BLD_IO.c KEYA_Can.c motor_state.c
  group Motor_Control/common
    ../Motor_Control/common/: controlFilter.c controller.c fuzzy.c idea.c smooth.c control_config.h
  group active_safety
    ../active_safety/: active_safety.c
  group Log
    ../log/: log_app.c SD_Driver.c SD_Log_App.c SD_Log_Driver.c log_app.h log_cmd.h SD_Driver.h SD_Log_App.h
  group fault_injector
    ../fault_injector/: fault_injector.c fault_injector_wrapper.c fault_injector.h fault_injector_wrapper.h
  group com
    ../com/: chassis_config.h chassis_list.h chassis_com.c chassis_com.h
  group alarm
    ../alarm/: alarm_com.c alarm_com.h
  group Temp_Sensor
    ../Temp_Sensor/: temp_sensor.c temp_sensor.h
  group stmflash
    ../stmfalsh/: flash_if.c flash_if.h
  group Unit_Test
    ../Unit_Test/: hard_fault_debug.c hard_fault_debug.h
  group FTP
    ../FTP/: ff_add.c ff_add.h FTP_APP.c FTP_APP.h ftpd.c ftpd.h util.c util.h
  group Zhd
    ../Zhd/: Zhd.c
  group Unity
    ../Unity-master/src/: unity.c
    ../Unity-master/extras/fixture/src/: unity_fixture.c
  group chassis_ut
    ../chassis_ut/: test_runner.c test_runner.h
    ../chassis_ut/test_cases/: test_alarm.c test_alarm.h test_bms.c test_bms.h test_control.c test_control.h test_ftp.c test_ftp.h test_imu.c test_imu.h test_joystick.c test_joystick.h test_log.c test_log.h test_odom.c test_odom.h test_temp_sensor.c test_temp_sensor.h test_ultrasonic.c test_ultrasonic.h test_zhd.c test_zhd.h
software components: CMSIS:CORE 4.3.0
